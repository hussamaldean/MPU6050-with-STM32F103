# Keil uVision project MPU6050_I2C.uvprojx, settings and files
target STM32F103C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050_I2C
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
  group RCC
    ./: rcc.c rcc.h
  group Helperv2
    ./: helperv2.c helperv2.h
  group UART1
    ./: UART.c UART.h
  group I2C
    ./: i2c.c i2c.h
  group MPU6050
    ./: MPU6050.c MPU6050.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
